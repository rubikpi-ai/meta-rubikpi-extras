SRC_URI = "file://${FWZIP_PATH}/${BOOTBINARIES}.zip"
