SRC_URI = "file://${FWZIP_PATH}/${HLOSFIRMWARE}.zip"
