SRC_URI = "file://${FWZIP_PATH}/${DSPSO}.zip"
